/*	# 	单总线代码片段说明
	1. 	本文件夹中提供的驱动代码供参赛选手完成程序设计参考�?
	2. 	参赛选手可以自行编写相关代码或以该代码为基础，根据所选单片机类型、运行速度和试�?
		中对单片机时钟频率的要求，进行代码调试和修改�?
*/
#include <STC15F2K60S2.H>
#include <intrins.h>
#include "onewire.h"

sbit DQ=P1^4;
//
void Delay_OneWire(unsigned int t)  
{
	unsigned char i;
	while(t--){
		for(i=0;i<27;i++);
	}
}
//
void Write_DS18B20(unsigned char dat)
{
	unsigned char i;
	for(i=0;i<8;i++)
	{
		DQ = 0;
		_nop_();_nop_();_nop_();_nop_();
		DQ = dat&0x01;
		Delay_OneWire(5);
		DQ = 1;
		dat >>= 1;
	}
	Delay_OneWire(5);
}

//
unsigned char Read_DS18B20(void)
{
	unsigned char i;
	unsigned char dat;
  
	for(i=0;i<8;i++)
	{
		DQ = 0;
		dat >>= 1;
		//_nop_();_nop_();_nop_();_nop_();
		DQ = 1;
		_nop_();_nop_();_nop_();_nop_();
		if(DQ)
		{
			dat |= 0x80;
		}	    
		Delay_OneWire(5);
	}
	return dat;
}

//
bit init_ds18b20(void)
{
  	bit initflag = 0;
  	
  	DQ = 1;
  	Delay_OneWire(12);
  	DQ = 0;
  	Delay_OneWire(80);
  	DQ = 1;
  	Delay_OneWire(10); 
    initflag = DQ;     
  	Delay_OneWire(5);
  
  	return initflag;
}

unsigned int Read_DS18B20_temp(void){
    unsigned char LSB,MSB;
    signed int raw;
    unsigned int temp;
	//		static unsigned char is_read=0;
	//		if(is_read==0){
	//		is_read=1;
	//		EA=0;
	//    if(init_ds18b20()){ EA=1; is_neg=0; return 0; }
			init_ds18b20();
		Write_DS18B20(0xCC);
		Write_DS18B20(0xBE);
		LSB = Read_DS18B20();
		MSB = Read_DS18B20();
	//    EA=1;
	//}
	//		else if(is_read){
	//		is_read=0;
	//    EA=0;
	//    if(init_ds18b20()){ EA=1; is_neg=0; return 0; }
			init_ds18b20();
		Write_DS18B20(0xCC);
		Write_DS18B20(0x44);
	//    EA=1;
	//}
    raw = (signed int)((MSB<<8)|LSB);
   if(raw < 0){ is_neg=1; raw=-raw; }
    else       { is_neg=0; }

    temp = (unsigned int)(raw * 625L / 100);
    return temp;
}